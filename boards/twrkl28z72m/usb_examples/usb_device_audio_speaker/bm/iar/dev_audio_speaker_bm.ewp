# IAR project dev_audio_speaker_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL28Z512xxx7 NXP MKL28Z512xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _DEBUG=1; CPU_MKL28Z512VLL7; USB_STACK_USE_DEDICATED_RAM=1; USB_STACK_BM; USING_SAI; TWR_KL28Z72M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../platform/drivers; ../../../../../../middleware/usb_1.6.3; ../../../../../../middleware/usb_1.6.3/osa; ../../../../../../middleware/usb_1.6.3/include; ../../../../../../middleware/usb_1.6.3/device; ../../../..; ../../../../../../devices/MKL28Z7/drivers; ../../../../../../devices/MKL28Z7/utilities; ../../../../../../devices/MKL28Z7
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dev_audio_speaker_bm.out
  ILINK.IlinkConfigDefines: __usb_use_usbram__=1
  ILINK.IlinkIcfFile: MKL28Z512xxx7_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MKL28Z512VLL7; USB_STACK_USE_DEDICATED_RAM=1; USB_STACK_BM; USING_SAI; TWR_KL28Z72M; TOWER
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group codec
    ../: fsl_sgtl5000.c fsl_sgtl5000.h
  group drivers
    ../../../../../../devices/MKL28Z7/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h
  group osa
    ../../../../../../middleware/usb_1.6.3/osa/: usb_osa.h usb_osa_bm.c usb_osa_bm.h
  group sources
    ../: audio_speaker.c audio_speaker.h sgtl5000_interface.c usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h
  group startup
    ../../../../../../devices/MKL28Z7/iar/: startup_MKL28Z7.s
    ../../../../../../devices/MKL28Z7/: system_MKL28Z7.c system_MKL28Z7.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/audio
    ../: usb_device_audio.c usb_device_audio.h
  group usb/device/include
    ../../../../../../middleware/usb_1.6.3/device/: usb_device.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.6.3/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../middleware/usb_1.6.3/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../middleware/usb_1.6.3/include/: usb_khci.h
  group usb/include
    ../../../../../../middleware/usb_1.6.3/include/: usb.h usb_misc.h usb_spec.h
  group utilities
    ../../../../../../devices/MKL28Z7/utilities/: fsl_debug_console.c fsl_debug_console.h
